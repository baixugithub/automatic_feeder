# Keil uVision project Fish.uvproj, settings and files
target Fish_Demo (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Fish +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Hardware\inc
  group user
    ../../user/src/: main.c
  group Hardware
    ../../Hardware/src/: lcd.c
  group startup
    ./: STARTUP.A51
  group description
    ../../: description.txt
